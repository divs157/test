# Keil uVision project 工程文件.uvprojx, settings and files
target STM32F103工程 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  Objects\工程文件.bin  Objects\工程文件.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\CMSIS\Include;..\HARDWARE\Inc;..\USER;..\STM32F1xx_HAL_Driver\Inc;..\CMSIS\Device\ST\STM32F1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/Scr/: delay.c usart.c boot.c stmflash.c timer.c 24c02.c iic.c spi.c w25qxx.c rtc.c stm32f1xx_it.c rcc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_timebase_tim_template.c
  group STM32F1xx_HAL_Driver
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group CMSIS
    ../CMSIS/Device/ST/STM32F1xx/Source/: system_stm32f1xx.c startup_stm32f103xb.s
  group New Group
    ./: text.c
