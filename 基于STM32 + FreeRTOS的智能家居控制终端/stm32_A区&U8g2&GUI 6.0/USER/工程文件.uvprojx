# Keil uVision project 工程文件.uvprojx, settings and files
target STM32F103工程 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  Objects\工程文件.bin  Objects\工程文件.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\CMSIS\Include;..\HARDWARE\Inc;..\CMSIS\Device\ST\STM32F1xx\Include;..\STM32F1xx_HAL_Driver\Inc;..\USER;..\HMAC\inc;..\FREERTOS\CMSIS_RTOS_V2;..\FREERTOS\Inc;..\FREERTOS\Port;..\FREERTOS;..\U8g2;..\OLED\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/Scr/: stm32f1xx_it.c delay.c usart.c led.c 24c02.c iic.c mqtt.c timer.c bh1750.c spi.c w25qxx.c wifi.c adc.c iot.c rcc.c rtc.c AHT10.c Encoder.c s12sd.c Key.c receiver.c rgb_led.c Message.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_msp_template.c
    ../HARDWARE/Inc/: stm32f1xx_hal_conf.h
  group STM32F1xx_HAL_Driver
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_exti.c
    ../../stm32_A区/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_i2c.c
  group CMSIS
    ../CMSIS/Device/ST/STM32F1xx/Source/: system_stm32f1xx.c startup_stm32f103xb.s
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
  group FREERTOS
    ../FREERTOS/CMSIS_RTOS_V2/: cmsis_os2.c
    ../FREERTOS/Port/: heap_4.c port.c
    ../FREERTOS/Src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FREERTOS/: FreeRTOSConfig.h
  group OLED
    ../OLED/Src/: i2c.c oled.c GUI.c menu.c Headline_1.c Subhead_1.c Subhead_2.c Subhead_3.c Subhead_4.c Subhead_5.c Subhead_1-1.c Subhead_1-2.c Subhead_1-3.c Subhead_4-1.c Subhead_4-2.c
  group U8g2
    ../U8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
